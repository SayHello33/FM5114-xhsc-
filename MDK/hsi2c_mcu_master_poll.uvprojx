# Keil uVision project hsi2c_mcu_master_poll.uvprojx, settings and files
target hsi2c_mcu_master_poll_Release (6090000::V6.9::.\ARMCLANG)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.0.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hsi2c_mcu_master_poll +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\user\inc;..\user\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l021.s
    ../../../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c flash.c hsi2c.c lpuart.c
    ../../../../driver/inc/: lpuart.h
  group README
    ../source/: main.c
    ../: readme.txt
  group user
    ../user/src/: uart.c FM5114.c LPCD_API.c MIFARE.c READER_API.c
    ../user/inc/: uart.h CPU_CARD.h DEFINE.h FM5114.h FM5114_REG.h LPCD_API.h LPCD_CFG.h MIFARE.h READER_API.h
    ./: DEFIN.c
software components: CMSIS:CORE 5.2.0
