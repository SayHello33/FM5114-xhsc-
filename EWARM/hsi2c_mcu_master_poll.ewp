# IAR project hsi2c_mcu_master_poll.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: HC32L021C8PB XHSC HC32L021C8PB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hsi2c_mcu_master_poll.hex
  ILINK.IlinkOutputFile: hsi2c_mcu_master_poll.out
  ILINK.IlinkIcfFile: HC32L021.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: hsi2c_mcu_master_poll.srec
  group common
    ../../../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
    ./: startup_hc32l021.s
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c flash.c gpio.c hsi2c.c sysctrl.c
  group source
    ../source/: main.c
  group README
    ../: readme.txt
